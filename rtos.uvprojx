# Keil uVision project rtos.uvprojx, settings and files
target stm32 (6240000::V6.24::ARMCLANG)
  device: STM32F411VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.13.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtos
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Src
    ./Src/: led.c uart.c osKernel.c main.c
  group Inc
    ./: led.h osKernel.h uart.h
software components: CMSIS:CORE 6.2.0, Device:Startup 2.6.2
